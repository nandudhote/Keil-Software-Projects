# Keil uVision project SSD_I2C.uvproj, settings and files
target SSD_I2C (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: SSD_I2C +hex
  c flags: Optimize=8
  c define: FOSC_160000
  c include: ..\Include
  group Source
    ./: main.c SS_Display.c SS_Display.h
  group Common
    ../Common/: Common.c Delay.c
  group Startup
    ../Startup/: STARTUP.A51
