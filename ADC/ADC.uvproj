# Keil uVision project ADC.uvproj, settings and files
target Target_1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: UART_Communication +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\N76E003_BSP_Keil_C51_V1.0.6;..\N76E003_BSP_Keil_C51_V1.0.6\N76E003_BSP_Keil_C51_V1.0.6\Common;..\N76E003_BSP_Keil_C51_V1.0.6\N76E003_BSP_Keil_C51_V1.0.6\Include
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../N76E003_BSP_Keil_C51_V1.0.6/N76E003_BSP_Keil_C51_V1.0.6/Common/: Common.c Delay.c
    ../N76E003_BSP_Keil_C51_V1.0.6/N76E003_BSP_Keil_C51_V1.0.6/Include/: Common.h Delay.h Function_Define.h N76E003.h SFR_Macro.h
